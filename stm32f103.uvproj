# Keil uVision project stm32f103.uvproj, settings and files
target iLib (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103
  c flags: Optim=1 oTime=1
  c include: .\src\lib\base\header;.\src\LenOS;.\src\LenOS\ads7843;.\src\LenOS\color;.\src\LenOS\font;.\src\LenOS\output;.\src\LenOS\Screen;.\src\LenOS\ssd1289;.\src\common;.\src\LenOS\data;.\src\LenOS\Touchable;.\src\LenOS\Touch;.\src\LenOS\data;.\src\lib\base;.\src\LenOS\Graphic;.\src\LenOS\Button;.\src;.\src\LenOS\User;.\src\LenOS\LenCar;.\src\LenOS\Idientify
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group __________________________________
    ./src/: main.cpp test.cpp UserMain.cpp UserMain.h
  group sys
    ./src/system/: startup_stm32f10x_hd.s isr.cpp sys.cpp
  group com
    ./src/common/: acom.s com.h com.cpp error.h
  group base&cnf
    ./src/lib/base/header/: base.h cnf.h
    ./src/lib/base/: base.cpp cnf.cpp
    ./src/LenOS/: led.h
  group system
    ./src/LenOS/: System.h System.cpp Process.h Process.cpp Interrupt.h Interrupt.cpp
  group driver
    ./src/LenOS/ads7843/: ads7843.h ads7843.cpp
    ./src/LenOS/ssd1289/: ssd1289.h ssd1289.cpp
  group interface
    ./src/LenOS/Touch/: touch.h touch.cpp
    ./src/LenOS/Screen/: screen.h screen.cpp
  group io
    ./src/LenOS/In/: In.h In.cpp
    ./src/LenOS/output/: Out.h Out.cpp
  group data base
    ./src/LenOS/data/: Vector.h Datas.h queue.h string.h string.cpp
    ./src/LenOS/font/: font.h font.cpp fontLib.cpp
  group attribute
    ./src/LenOS/Graphic/: Paintable.cpp Paintable.h
    ./src/LenOS/Touchable/: touchable.h touchable.cpp
  group graphic
    ./src/LenOS/Graphic/: Graphic.h Graphic.cpp
    ./src/LenOS/Color/: color.h color.cpp
  group widgets_base
    ./src/LenOS/Graphic/: widget.h widget.cpp touchWidget.h touchWidget.cpp
  group widgets
    ./src/LenOS/User/: MessageBox.cpp MessageBox.h
    ./src/LenOS/Button/: Button.h Button.cpp
    ./src/LenOS/Graphic/: ControlPad.h ControlPad.cpp text.h text.cpp textBox.h textBox.cpp Slider.h Slider.cpp
  group window_base
    ./src/LenOS/Graphic/: pad.h pad.cpp touchPad.h touchPad.cpp
  group window
    ./src/LenOS/Graphic/: window.h window.cpp
  group UI
    ./src/LenOS/User/: GUI.h DUI.h SYS.h WGT.h
  group LenCar
    ./src/LenOS/LenCar/: lenCar.h lenCar.cpp
  group funcGen
    ./src/project/funcGen/: FuncGen.cpp FuncGen.h
  group Idientify
    ./src/LenOS/Idientify/: handData.cpp hand.cpp hand.h
target iProject (ARM-ADS)
  device: STM32F101ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32f103
  c flags: Optim=1
  c include: .\src\common\header;.\src\lib\base\header;.\src\lib\cnf\header;.\src\lib\core\header;.\src\peripheral\ads7483\header;.\src\peripheral\devboard\header;.\src\peripheral\ds18b20\header;.\src\peripheral\ssd1289\header;.\src\project\adconverter\header;.\src\resouce\bitmap\header;.\src\resouce\font\header;.\src\system;.\src;.\src\debug;.\src\project\widget\button\header;.\src\lenfien;.\src\project\daconverter\header;.\src\project\steerEngine\header;.\src\project\widget\windows
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xc000
